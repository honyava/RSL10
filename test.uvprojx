# Keil uVision project test.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: RSL10 ONSemiconductor
  pack: ONSemiconductor.RSL10.3.8.801
  cpu: IRAM(0x20000000,0x6000) IROM(0x00100000,0x60000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1 v6Lang=6 v6LangP=3 wLevel=3
  c define: RSL10_CID=101, USE_STDPERIPH_DRIVER
  c misc: -fno-short-wchar -fshort-enums
  c include: ..\RSL10
  asm define: RSL10_CID=101, USE_STDPERIPH_DRIVER
  asm include: ..\RSL10
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: .\RTE\Device\RSL10\sections.sct
  link misc: --show_full_path --show_parent_lib
  group Source Group 1
    ./: main.c main.h
software components: CMSIS:CORE 5.6.0, Device:Libraries:System 3.8.801, Device:Startup 3.8.801, Utility:IO:Printf wrapper 3.8.801, Utility:IO:SEGGER RTT 3.8.801
